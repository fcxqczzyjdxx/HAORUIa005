# Keil uVision project project.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,STM32F10xxx
  c include: ..\user;..\system;..\system\startup;..\system\startup\arm;..\system\STM32F10x_StdPeriph_Driver\inc;..\system\my_lib;..\hardware;..\config;..\device_driver\sim800c;..\mqtt;..\onenet
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group start
    ../system/startup/arm/: startup_stm32f10x_hd.s
  group hardware
    ../hardware/: gpio.c in_adc.c in_photocoupler.c out_led.c out_relay.c timer.c uart.c stm32_flash.c
  group system
    ../system/: delay.c system.c
  group user
    ../user/: main.c stm32f10x_it.c
  group config
    ../config/: config.c
  group system\FWlib
    ../system/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group system\startup
    ../system/startup/: system_stm32f10x.c core_cm3.c
  group system\my_lib
    ../system/my_lib/: my_lib.c
  group doc
    ../doc/: readme.txt
  group device_driver\sim800c
    ../device_driver/sim800c/: sim800c.c sim800c.h
  group mqtt
    ../mqtt/: mqtt.c mqtt.h
  group onenet
    ../onenet/: onenet.c onenet.h
