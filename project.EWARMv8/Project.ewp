# IAR project Project.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VE ST STM32F103VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\device_driver\sim800c; ..\hardware; ..\libraries\my_lib; ..\libraries\STM32F10x_StdPeriph_Driver\inc; ..\libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar; ..\system; ..\user; $TOOLKIT_DIR$\CMSIS\Core\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  AARM.AUserIncludes: ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar
  OBJCOPY.OOCOutputFile: Project.hex
  postbuild: CopyHex_Flash.bat
  ILINK.IlinkOutputFile: stm32-f3.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CpuRAM (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; VECT_TAB_SRAM
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Libraries\CMSIS\Include; ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\User\bsp_stm32f4xx; ..\..\User\bsp_stm32f4xx\inc; ..\..\User
  ICCARM.CCOptLevel: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: stm32-f4.out
  ILINK.IlinkIcfFile: stm32f4xx_ram.icf
  group doc
    ../doc/: IAR配置注意.txt readme.txt 硬件连接.txt
  group hardware
    ../hardware/: adc.c gpio.c inner_flash.c led.c relay.c usart1.c
  group libraries/CMSIS
    ../libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    ../libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group libraries/my_lib
    ../libraries/my_lib/: arm_c_lib.h arm_cpp_lib.h my_lib.c my_lib.h
  group libraries/STM32F10x_StdPeriph_Driver
    ../libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group system
    ../system/: delay.c usart.c
  group user
    ../user/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
